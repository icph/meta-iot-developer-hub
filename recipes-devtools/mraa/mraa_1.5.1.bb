require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=6f9b470d8d25e2c8ba1586cd9d707b870ab30010 \
           file://ConfigurableFirmataCurieImu.ino.bin \
           file://imraa.service \
           file://imraa.conf \
          "

FILESEXTRAPATHS_append := "${THISDIR}/files"
SRC_URI += "file://0001-firefox-add-.desktop-to-xdg-autostart-directory.patch \
            file://0002-firefox-change-homepage-to-devhub-startup-page.patch"
